# Keil uVision project ds18b20.uvprojx, settings and files
target lpc1114_ds18b20 (ARM-ADS)
  device: LPC1114FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ds18b20
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\delay;..\ds18b20;..\key;..\lpc11xx;..\oled;..\uart
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group user
    ./user/: main.c
  group delay
    ../delay/: delay.c
  group lpc11xx
    ../lpc11xx/: startup_LPC11xx.s system_LPC11xx.c
  group oled
    ../oled/: Function_Display.c oled.c
  group ds18b20
    ../ds18b20/: ds18b20.c
  group uart
    ../uart/: uart.c
